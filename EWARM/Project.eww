<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Led_Blink_BM.ewp</path>
  </project>
  <batchBuild />
</workspace>
